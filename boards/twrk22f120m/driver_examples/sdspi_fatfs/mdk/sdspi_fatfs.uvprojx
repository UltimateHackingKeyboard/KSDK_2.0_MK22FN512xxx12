# Keil uVision project sdspi_fatfs.uvprojx, settings and files
target sdspi_fatfs Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sdspi_fatfs.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VDC12, TWR_K22F120M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MK22F51212/drivers;../../../../../middleware/fatfs_0.11a/src;../../../../../middleware/fatfs_0.11a/src/fsl_sdspi_disk;..;../../../../../devices/MK22F51212/utilities;../../../../../middleware/sdmmc_2.0.0/inc;../../../../../middleware/sdmmc_2.0.0/src;../../..;../../../../../devices/MK22F51212
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MK22F51212/arm/: startup_MK22F51212.s
    ../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK22F51212/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_dspi.h fsl_dspi.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group source
    ../: sdspi_fatfs.c ffconf.h
  group FATFS_Source
    ../../../../../middleware/fatfs_0.11a/src/fsl_sdspi_disk/: fsl_sdspi_disk.c fsl_sdspi_disk.h
    ../../../../../middleware/fatfs_0.11a/src/: integer.h ff.c ff.h diskio.c diskio.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
  group sdspi-src
    ../../../../../middleware/sdmmc_2.0.0/src/: fsl_sdspi.c
  group sdspi-inc
    ../../../../../middleware/sdmmc_2.0.0/inc/: fsl_sdspi.h fsl_specification.h
target sdspi_fatfs Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: sdspi_fatfs.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VDC12, TWR_K22F120M, TOWER
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK22FN512xxx12_flash.scf
  link misc: --remove
