# IAR project dev_phdc_weighscale_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK22FN512VDC12; USB_STACK_BM; TWR_K22F120M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MK22F51212/utilities; ../../../../../../middleware/usb_1.0.0; ../../../../../../middleware/usb_1.0.0/osa; ../../../../../../middleware/usb_1.0.0/include; ../../../../../../middleware/usb_1.0.0/device; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../devices/MK22F51212/drivers; ../../../../../../devices/MK22F51212
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_phdc_weighscale_bm.out
  ILINK.IlinkIcfFile: MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK22FN512VDC12; USB_STACK_BM; TWR_K22F120M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK22F51212/iar/: startup_MK22F51212.s
    ../../../../../../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.0.0/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb_1.0.0/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/phdc
    ../: usb_device_phdc.c usb_device_phdc.h
  group usb/device/include
    ../../../../../../middleware/usb_1.0.0/device/: usb_device.h
  group usb/include
    ../../../../../../middleware/usb_1.0.0/include/: usb.h
  group drivers
    ../../../../../../devices/MK22F51212/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../../middleware/usb_1.0.0/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group sources
    ../: usb_device_descriptor.c usb_device_descriptor.h usb_shim_agent.c usb_shim_agent.h weighscale.c weighscale.h usb_device_config.h
  group sources/ieee11073_agent
    ../: ieee11073_agent.c ieee11073_agent.h ieee11073_types.h ieee11073_timer.c ieee11073_timer.h
  group utilities
    ../../../../../../devices/MK22F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
